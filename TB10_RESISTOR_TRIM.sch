** sch_path: TB10_RESISTOR_TRIM.sch
**.subckt TB10_RESISTOR_TRIM
x1 avdd 0 vref b0 b1 b2 b3 b4 b5 b6 0 dvdd Bandgap_Core_Res
VDD avdd 0 3.3
VDVDD dvdd 0 3.3
VBIT0 b0 0 0
VBIT1 b1 0 0
VBIT2 b2 0 0
VBIT3 b3 0 0
VBIT4 b4 0 0
VBIT5 b5 0 0
VBIT6 b6 0 0
**** begin user architecture code
[read_data_nonewline [abs_sym_path trim_testbench/generated/manual_setup.spice]]
**** end user architecture code
**.ends
.end
